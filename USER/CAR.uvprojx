# Keil uVision project CAR.uvprojx, settings and files
target CAR (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAR +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\SYSTEM\delay;..\STM32F10x_FWLib\SYSTEM\sys;..\STM32F10x_FWLib\SYSTEM\usart;..\HARDWARE\TIMER;..\HARDWARE\5110;..\HARDWARE\AD;..\HARDWARE\PID;..\HARDWARE\KEY;..\HARDWARE\speed;..\HARDWARE\GUI
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c user.c stm32f10x_it.c system_stm32f10x.c include.h stmflash.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_dac.c stm32f10x_dma.c
  group SYSTEM
    ../STM32F10x_FWLib/SYSTEM/delay/: delay.c
    ../STM32F10x_FWLib/SYSTEM/sys/: sys.c
    ../STM32F10x_FWLib/SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/Speed/: speed.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/AD/: ADC.c
    ../HARDWARE/PID/: PID.C
    ../HARDWARE/KEY/: KEY.C
    ../HARDWARE/5110/: LCD5110.c
    ../HARDWARE/GUI/: gui.c
  group Readme
    ../: Readme.txt
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0
